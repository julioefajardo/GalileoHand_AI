# Keil uVision project TouchScreen.uvprojx, settings and files
target BGH_TouchScreen (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TouchScreen +hex
  c flags: Optim=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA0
  c misc: --c99
  c include: ..;..\..\..\..
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ./: main.c ustdlib.c
    ./drivers/: Kentec320x240x16_ssd2119_8bit.c touch.c
    ./RTE/Device/TM4C1294NCPDT/: startup_rvmdk.S
  group Lib
    ../../../../grlib/rvmdk/: grlib.lib
    ../../../../driverlib/rvmdk/: driverlib.lib
  group AI
    ./AI/: NeuralNetworkFunction.c NeuralNetworkFunction_initialize.c NeuralNetworkFunction_terminate.c rt_nonfinite.c rtGetInf.c rtGetNaN.c
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2
